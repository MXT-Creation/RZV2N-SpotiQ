RDEPENDS_${PN} += "\
 nativesdk-python3-numpy \
"
