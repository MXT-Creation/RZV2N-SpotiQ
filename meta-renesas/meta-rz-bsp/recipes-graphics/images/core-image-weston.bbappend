require include/core-image-bsp.inc
require include/core-image-renesas-mmp.inc
