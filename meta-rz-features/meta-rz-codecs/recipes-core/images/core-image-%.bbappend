require include/codec_packages.inc

TOOLCHAIN_TARGET_TASK:append = " drp "
