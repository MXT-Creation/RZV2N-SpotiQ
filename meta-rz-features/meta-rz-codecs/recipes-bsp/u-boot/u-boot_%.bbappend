FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_r9a09g057 = " \
	file://0001_Add_OpenCVA_and_Codec.patch \
"

SRC_URI_append_r9a09g056 = " \
	file://0001-Add-OpenCVA-and-Codec-for-V2N.patch \
"
