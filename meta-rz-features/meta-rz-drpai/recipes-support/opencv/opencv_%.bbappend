PACKAGECONFIG:append:pn-opencv = " gtk"
PACKAGECONFIG:append:pn-nativesdk-opencv = " gtk"
