RDEPENDS:perl-module-gdbm-file += "gdbm"
RDEPENDS:perl-module-ndbm-file += "gdbm-compat"
