SUMMARY = "Python library to parse and build SubRip (.srt) subtitle files"
HOMEPAGE = "https://pypi.org/project/srt/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6658a1272b4469f7249985d28b8697bb"

PYPI_PACKAGE = "srt"
SRC_URI[sha256sum] = "4884315043a4f0740fd1f878ed6caa376ac06d70e135f306a6dc44632eed0cc0"

inherit pypi setuptools3
